options:
  parameters:
    author: Camila Vinza
    generate_options: qt_gui
    id: QAM_MOD
    output_language: python
    title: Modulación QAM
  states: {}

blocks:
- name: decimation
  id: variable
  parameters:
    value: interpolation
  states: {}
- name: freq_rds
  id: variable
  parameters:
    value: 90e6
  states: {}
- name: gainrx
  id: variable_qtgui_range
  parameters:
    label: GananciaRx
    start: '1'
    step: '1'
    stop: '100'
    value: '45'
  states: {}
- name: gaintx
  id: variable_qtgui_range
  parameters:
    label: GananciaTx
    start: '1'
    step: '1'
    stop: '100'
    value: '45'
  states: {}
- name: interpolation
  id: variable
  parameters:
    comment: Interpolation = decimation
    value: '60'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: samp_rate_RDS
  id: variable
  parameters:
    value: samp_rate*interpolation
  states: {}
- name: selector
  id: variable_qtgui_chooser
  parameters:
    label: mensaje
    label0: Audio 1
    label1: Audio 2
    num_opts: '2'
    option0: '0'
    option1: '1'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: vol
  id: variable_qtgui_range
  parameters:
    label: volumen
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: analog_const_source_1
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-8e3'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: Portadora Coseno
    freq: 8e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: Portadora seno
    freq: '-8e3'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 8e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: '0.8'
    type: complex
  states: {}
- name: blocks_multiply_const_xx_0_0
  id: blocks_multiply_const_xx
  parameters:
    const: '2'
    type: float
  states: {}
- name: blocks_multiply_const_xx_0_0_0
  id: blocks_multiply_const_xx
  parameters:
    const: '2'
    type: float
  states: {}
- name: blocks_multiply_const_xx_0_1
  id: blocks_multiply_const_xx
  parameters:
    const: vol
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: selector
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    comment: Señal de audio 1
    file: /home/robert/Music/first-love-letra-lyric.wav
    repeat: 'True'
  states: {}
- name: blocks_wavfile_source_0_0
  id: blocks_wavfile_source
  parameters:
    comment: Señal de audio 2.
    file: /home/robert/Music/blue-zone-remix-2023-atlegal-ec-on-tiktok.wav
    repeat: 'True'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 8e3
    decim: '1'
    gain: '2'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 8e3
    decim: '1'
    gain: '2'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"ESPECTRO DE TRANSMISIÓN"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"RECEPCION"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: interpolation
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: decimation
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: 100e3
    center_freq0: freq_rds
    comment: Transmisor USRP
    dev_addr: '"serial=30875AE"'
    gain0: gaintx
    samp_rate: samp_rate_RDS
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: 100e3
    center_freq0: freq_rds
    comment: Receptor USRP
    dev_addr: '"serial=30875AE"'
    gain0: gainrx
    samp_rate: samp_rate_RDS
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_const_source_1, '0', blocks_float_to_complex_0, '1']
- [analog_const_source_x_0_0, '0', blocks_float_to_complex_0_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0_1, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0_0, '0', blocks_multiply_xx_0_0, '0']
- [analog_sig_source_x_0_0_1, '0', blocks_multiply_xx_0_0_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_add_xx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_multiply_const_xx_0_1, '0']
- [blocks_complex_to_mag_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0, '0']
- [blocks_float_to_complex_0_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_multiply_const_xx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_multiply_const_xx_0_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_const_xx_0_0_0, '0', low_pass_filter_0_0, '0']
- [blocks_multiply_const_xx_0_1, '0', audio_sink_0, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_xx_0_0_0, '0', low_pass_filter_0_1, '0']
- [blocks_multiply_xx_0_1, '0', low_pass_filter_0_0_0, '0']
- [blocks_selector_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_wavfile_source_0, '0', blocks_multiply_const_xx_0_0, '0']
- [blocks_wavfile_source_0_0, '0', blocks_multiply_const_xx_0_0_0, '0']
- [low_pass_filter_0, '0', blocks_float_to_complex_0, '0']
- [low_pass_filter_0_0, '0', blocks_float_to_complex_0_0, '0']
- [low_pass_filter_0_0_0, '0', blocks_selector_0, '1']
- [low_pass_filter_0_1, '0', blocks_selector_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_xx_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_multiply_xx_0_0_0, '1']
- [rational_resampler_xxx_0_0, '0', blocks_multiply_xx_0_1, '0']
- [uhd_usrp_source_0, '0', rational_resampler_xxx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
